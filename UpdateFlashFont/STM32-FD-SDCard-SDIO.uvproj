# Keil uVision project STM32-FD-SDCard-SDIO.uvproj, settings and files
target TestDemo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TestDemo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\Core;.\Fatfs\inc;.\FWlib\inc;.\HardWare\inc;.\Malloc;.\Picture\inc;.\System\inc;.\User\inc;.\Json;.\crc32;.\os;.\Text;.\Task\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/src/: main.c stm32f10x_it.c system_stm32f10x.c app_task.c
  group FWLib
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_spi.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group Fatfs
    ./Fatfs/src/: diskio.c ff.c
  group Picture
    ./Picture/src/: data_parse.c jpg_create.c piclib.c tjpgd.c gif.c
  group HardWare
    ./HardWare/src/lcd/: lcd.c
    ./HardWare/src/sd/: sdcard.c
    ./HardWare/src/sram/: fsmc_sram.c
    ./HardWare/src/sim900a/: sim900a.c
    ./HardWare/src/key/: keys.c
    ./HardWare/src/flash/: flash.c
    ./HardWare/src/spi/: spi.c
  group System
    ./System/src/delay/: delay.c
    ./System/src/timer/: timer.c
    ./System/src/usart/: usart.c
  group Malloc
    ./Malloc/: malloc.c
  group Json
    ./Json/: cjsonutil.c cJSON.c
  group Crc32
    ./crc32/: crc32.c
  group OS
    ./os/: liblist.c libtimer.c
  group Text
    ./Text/: text.c fontupd.c
  group Task
    ./Task/src/: getimage.c getqrcodelist.c getscancodelist.c getversion.c
